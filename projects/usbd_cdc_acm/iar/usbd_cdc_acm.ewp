# IAR project usbd_cdc_acm.ewp, settings and files
configuration usbd_cdc_acm (ARM, debug)
  General.OGChipSelectEditMenu: OM6627X Onmicro OM6627X
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 67
  General.FPU2: 4
  ICCARM.CCDefines: OM6627X=1; CONFIG_HARDWARE_VERSION=1
  ICCARM.CCDiagSuppress: Pe111,Pe177,Pe128,Ta022,Ta023
  ICCARM.CCIncludePath2: ../config; ../../../bsp/include; ../../../common/include; ../../../common/source; ../../../components/shell; ../../../components/manu_system/fault_handle; ../../../components/om_log; ../../../components/evt; ../../../components/CherryUSB; ../../../components/CherryUSB/common; ../../../components/CherryUSB/core; ../../../components/CherryUSB/class/cdc; ../../../components/CherryUSB/class/msc; ../../../components/CherryUSB/class/hid; ../../../components/CherryUSB/class/audio; ../../../components/CherryUSB/class/video; ../../../components/CherryUSB/class/wireless; ../../../components/CherryUSB/class/dfu; ../../../components/CherryUSB/class/midi; ../../../components/CherryUSB/class/vendor/net; ../../../components/CherryUSB/class/vendor/serial; ../../../components/pm; ../../../hal/CMSIS/Core/Include; ../../../hal/driver/include; ../../../hal/device/include; ../../../rtos/include; ../../../rtos/FreeRTOS/Source/Include; ../../../rtos/FreeRTOS/CMSIS/Include; ../../../rtos/FreeRTOS/CMSIS/Include1; ../../../rtos/FreeRTOS/CMSIS/Config/ARMCM; ../../../rtos/FreeRTOS/Source/Portable/IAR
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: OM6627X=1; CONFIG_HARDWARE_VERSION=1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ../\usbd_cdc_acm.bin
  ILINK.IlinkOutputFile: usbd_cdc_acm.out
  ILINK.IlinkIcfFile: ../linker_script/IAR/cm4f_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../hal/device/IAR/libcpft.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group main
    ../main/: main.c evt_task.c system.c app_cdc_acm.c
  group bsp
    ../../../bsp/board_evb/: board_evb.c
    ../../../bsp/source/: glcd_gc9c01.c glcd_gc9b71.c
  group common
    ../../../common/source/: om_printf.c om_mem.c om_ringbuff.c om_common.c om_fifo.c om_libc_retarget.c om_list.c
  group shell
    ../../../components/shell/: shell_common.c shell_port_rtos.c
  group manu_system
    ../../../components/manu_system/fault_handle/: fault_handle.c
  group om_log
    ../../../components/om_log/: om_log.c om_log_port.c
  group evt
    ../../../components/evt/: evt.c evt_timer.c
  group CherryUSB
    ../../../components/CherryUSB/core/: usbd_core.c
    ../../../components/CherryUSB/osal/: usb_osal_freertos.c
    ../../../components/CherryUSB/port/musb/: usb_dc_musb.c usb_glue_om.c
    ../../../components/CherryUSB/class/cdc/: usbd_cdc_acm.c
  group pm
    ../../../components/pm/: pm.c pm_cpu_iar.S
  group driver
    ../../../hal/driver/source/: drv_mpu.c drv_om24g.c drv_gpadc.c drv_aes.c drv_calib_repair.c drv_calib.c drv_gpdma.c drv_efuse.c drv_gpio.c drv_i2c.c drv_isr.c drv_lptim.c drv_pin.c drv_pmu_timer.c drv_pmu.c drv_radio.c drv_rcc.c drv_rng.c drv_rtc.c drv_spi.c drv_tim.c drv_uart.c drv_wdt.c drv_i2s.c drv_audio.c drv_audio_inside.c drv_audio_outside.c drv_lcd.c drv_irtx.c drv_sha256.c drv_ospi.c drv_psram.c drv_qdec.c drv_rgb.c
    ../../../hal/driver/source/drv_ecdsa/: drv_ecdsa.c
    ../../../hal/driver/source/drv_ecdsa/uECC/: uECC.c
    ../../../hal/driver/source/drv_flash/: drv_iflash.c drv_oflash.c drv_flash.c
  group startup
    ../../../hal/device/: system_cm4f.c
    ../../../hal/device/IAR/: startup_cm4f.S
  group FreeRTOS
    ../../../rtos/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../rtos/FreeRTOS/Source/Portable/MemMang/: heap_5.c
    ../../../rtos/FreeRTOS/Source/Portable/Common/: mpu_wrappers.c
    ../../../rtos/FreeRTOS/CMSIS/Source/: cmsis_os2.c cmsis_os1.c freertos_evr.c os_systick.c
    ../../../rtos/FreeRTOS/Source/Portable/IAR/: port.c portasm.s
