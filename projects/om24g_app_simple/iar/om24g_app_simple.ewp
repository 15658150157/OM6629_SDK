# IAR project om24g_app_simple.ewp, settings and files
configuration om24g_app_simple (ARM, debug)
  General.OGChipSelectEditMenu: OM6627X Onmicro OM6627X
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: OM6627X=1; CONFIG_HARDWARE_VERSION=1
  ICCARM.CCDiagSuppress: Pe111,Pe177,Pe128
  ICCARM.CCIncludePath2: ../config; ../../../bsp/include; ../../../common/include; ../../../common/source; ../../../components/shell; ../../../components/om_log; ../../../components/nvds; ../../../components/evt; ../../../components/pm; ../../../hal/CMSIS/Core/Include; ../../../hal/driver/include; ../../../hal/device/include; ../../../rtos/include; ../../../rtos/FreeRTOS/Source/Include; ../../../rtos/FreeRTOS/CMSIS/Include; ../../../rtos/FreeRTOS/CMSIS/Include1; ../../../rtos/FreeRTOS/CMSIS/Config/ARMCM; ../../../rtos/FreeRTOS/Source/Portable/IAR
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: OM6627X=1; CONFIG_HARDWARE_VERSION=1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ../\om24g_app_simple.bin
  ILINK.IlinkOutputFile: om24g_app_simple.out
  ILINK.IlinkIcfFile: D:\work.pro\om6627\trunk\SDK\projects\om24g_app_simple\linker_script\IAR\cm4f_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../../../bsp/board_evb/: board_evb.c
    ../../../bsp/source/: glcd_gc9b71.c glcd_gc9c01.c
  group common
    ../../../common/source/: om_common.c om_fifo.c om_libc_retarget.c om_list.c om_mem.c om_printf.c om_ringbuff.c
  group driver
    ../../../hal/driver/source/: drv_aes.c drv_audio.c drv_audio_inside.c drv_audio_outside.c drv_calib.c drv_calib_repair.c drv_efuse.c drv_gpadc.c drv_gpdma.c drv_gpio.c drv_i2c.c drv_i2s.c drv_irtx.c drv_isr.c drv_lcd.c drv_lptim.c drv_mpu.c drv_om24g.c drv_ospi.c drv_pin.c drv_pmu.c drv_pmu_timer.c drv_psram.c drv_qdec.c drv_radio.c drv_rcc.c drv_rgb.c drv_rng.c drv_rtc.c drv_sha256.c drv_spi.c drv_tim.c drv_uart.c drv_wdt.c
    ../../../hal/driver/source/drv_ecdsa/: drv_ecdsa.c
    ../../../hal/driver/source/drv_flash/: drv_flash.c drv_iflash.c drv_oflash.c
    ../../../hal/driver/source/drv_ecdsa/uECC/: uECC.c
  group evt
    ../../../components/evt/: evt.c evt_timer.c
  group FreeRTOS
    ../../../rtos/FreeRTOS/CMSIS/Source/: cmsis_os1.c cmsis_os2.c freertos_evr.c os_systick.c
    ../../../rtos/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../rtos/FreeRTOS/Source/Portable/MemMang/: heap_5.c
    ../../../rtos/FreeRTOS/Source/Portable/Common/: mpu_wrappers.c
    ../../../rtos/FreeRTOS/Source/Portable/IAR/: port.c portasm.s
  group main
    ../main/: app_om24g.c main.c
  group nvds
    ../../../components/nvds/: nvds.c
  group om_log
    ../../../components/om_log/: om_log.c om_log_port.c
  group pm
    ../../../components/pm/: pm.c pm_cpu_iar.S
  group shell
    ../../../components/shell/: shell_common.c shell_port_rtos.c
  group startup
    ../../../hal/device/IAR/: startup_cm4f.S
    ../../../hal/device/: system_cm4f.c
