# IAR project ble_app_mesh.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: OM6627 Onmicro OM6627
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: OM6627X=1; CONFIG_HARDWARE_VERSION=1; CONFIG_OM_LOG; CONFIG_OM_LOG_TO_UART; CONFIG_LE_BROADCASTER=1; CONFIG_LE_OBSERVER=1; CONFIG_LE_PERIPHERAL=1; CONFIG_LE_CENTRAL=1; CONFIG_LE_ACTIVITY_NB=10; CONFIG_LE_CONNECTION_NB=2; CONFIG_LE_WHITELIST_NB=6; CONFIG_LE_LL_HCI_CMD_PKTS_NB=2; CONFIG_LE_LL_RX_DATA_BUF_NB=3; CONFIG_LE_LL_RX_DATA_BUF_SIZE=256; CONFIG_LE_LL_TX_ACL_BUF_NB=3; CONFIG_LE_LL_TX_ACL_BUF_SIZE=256; CONFIG_LE_LL_TX_ADV_BUF_NB=5; CONFIG_LE_LL_TX_ADV_FRAG_NB=2; CONFIG_LE_LL_TX_ADV_FRAG_BUF_SIZE=254; CONFIG_LE_LL_TX_LLCP_BUF_NB=11; CONFIG_BLE_HOST=1
  ICCARM.CCIncludePath2: ..\config; ..\..\..\common\include; ..\..\..\common\source; ..\..\..\components\ble\include; ..\..\..\components\ble\controller\include; ..\..\..\components\ble\host\include; ..\..\..\components\evt; ..\..\..\components\nvds; ..\..\..\components\om_log; ..\..\..\components\pm; ..\..\..\components\shell; ..\..\..\hal\CMSIS\Core\Include; ..\..\..\hal\device\include; ..\..\..\hal\device\IAR; ..\..\..\hal\driver\include; ..\..\..\rtos\include; ..\..\..\rtos\FreeRTOS\Source\Include; ..\..\..\rtos\FreeRTOS\CMSIS\Include1; ..\..\..\rtos\FreeRTOS\CMSIS\Include; ..\..\..\rtos\FreeRTOS\CMSIS\Config\ARMCM; ..\..\..\rtos\FreeRTOS\Source\Portable\IAR; ..\..\..\components\ble\mesh\include; ..\app; ..\app\firms; ..\app\tmall; ..\..\..\bsp\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\rtos\FreeRTOS\CMSIS\Config\ARMCM
  OBJCOPY.OOCOutputFile: ble_app_mesh.bin
  ILINK.IlinkOutputFile: ble_app_mesh.out
  ILINK.IlinkIcfFile: ..\linker_script\IAR\cm4f_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app
    ../app/: omsh_app.c omsh_app_hook.c omsh_app_shell.c
  group app_firms
    ../app/firms/: omsh_app_firms.c omsh_app_firms_mdl.c omsh_app_firms_mdl_demo.c
  group app_tmall
    ../app/tmall/: omsh_app_tmall.c
  group ble_mem
    ../../../components/ble/common/: ob_mem_heap.c
  group board
    ../../../bsp/board_evb/: board_evb.c
  group common
    ../../../common/source/: om_common.c om_fifo.c om_libc_retarget.c om_list.c om_mem.c om_printf.c om_ringbuff.c
  group driver
    ../../../hal/driver/source/: drv_aes.c drv_audio.c drv_audio_inside.c drv_audio_outside.c drv_calib.c drv_calib_repair.c drv_efuse.c drv_gpadc.c drv_gpdma.c drv_gpio.c drv_i2c.c drv_i2s.c drv_irtx.c drv_isr.c drv_lcd.c drv_lptim.c drv_mpu.c drv_om24g.c drv_ospi.c drv_pin.c drv_pmu.c drv_pmu_timer.c drv_psram.c drv_qdec.c drv_radio.c drv_rcc.c drv_rgb.c drv_rng.c drv_rtc.c drv_sha256.c drv_spi.c drv_tim.c drv_uart.c drv_wdt.c
    ../../../hal/driver/source/drv_ecdsa/: drv_ecdsa.c
    ../../../hal/driver/source/drv_flash/: drv_flash.c drv_iflash.c drv_oflash.c
    ../../../hal/driver/source/drv_ecdsa/uECC/: uECC.c
  group evt
    ../../../components/evt/: evt.c evt_timer.c
  group lib
    ../../../components/ble/controller/lib/IAR/: libblectlr_full.a
    ../../../components/ble/host/lib/IAR/: libblehost_full.a
    ../../../components/ble/mesh/lib/IAR/: libblemesh.a
  group log
    ../../../components/om_log/: om_log.c om_log_port.c
  group main
    ../main/: main.c
  group nvds
    ../../../components/nvds/: nvds.c
  group pm
    ../../../components/pm/: pm.c pm_cpu_iar.S
  group rtos
    ../../../rtos/FreeRTOS/CMSIS/Source/: cmsis_os2.c freertos_evr.c os_systick.c
    ../../../rtos/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../rtos/FreeRTOS/Source/Portable/MemMang/: heap_5.c
    ../../../rtos/FreeRTOS/Source/Portable/IAR/: port.c portasm.s
  group shell
    ../../../components/shell/: shell_common.c shell_port_rtos.c
  group startup
    ../../../hal/device/IAR/: startup_cm4f.S
    ../../../hal/device/: system_cm4f.c
