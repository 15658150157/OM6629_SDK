# Keil uVision project ble_app_mesh.uvprojx, settings and files
target ble_app_mesh (6140000::V6.14::ARMCLANG)
  device: OM6627X Onmicro
  pack: Onmicro.OM6627X.1.0.0
  cpu: IROM(0x00400000,0x400000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(64000000) ELITTLE
  output: ble_app_mesh
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "#L"
  AfterMake: fromelf.exe -c --output "$L@L.dis" "#L"
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CONFIG_BLE_HOST,CONFIG_LE_BROADCASTER=1,CONFIG_LE_OBSERVER=1,CONFIG_LE_PERIPHERAL=1,CONFIG_LE_CENTRAL=1,CONFIG_LE_ACTIVITY_NB=10,CONFIG_LE_CONNECTION_NB=8,CONFIG_LE_WHITELIST_NB=6,CONFIG_LE_LL_HCI_CMD_PKTS_NB=2,CONFIG_LE_LL_RX_DATA_BUF_NB=3,CONFIG_LE_LL_RX_DATA_BUF_SIZE=256,CONFIG_LE_LL_TX_ACL_BUF_NB=3,CONFIG_LE_LL_TX_ACL_BUF_SIZE=256,CONFIG_LE_LL_TX_ADV_BUF_NB=5,CONFIG_LE_LL_TX_ADV_FRAG_NB=2,CONFIG_LE_LL_TX_ADV_FRAG_BUF_SIZE=254,CONFIG_LE_LL_TX_LLCP_BUF_NB=11,OM6627X=1,
  c include: ../config;../app;../app/firms;../app/tmall;../../../bsp/include;../../../common/include;../../../common/source;../../../components/ble/include;../../../components/ble/controller/include;../../../components/ble/host/include;../../../components/ble/profile/om_ancs;../../../components/ble/profile/om_bms;../../../components/ble/profile/om_cgms;../../../components/ble/profile/om_dfu;../../../components/ble/profile/om_gap_dis_batt;../../../components/ble/profile/om_hid_media;../../../components/ble/profile/om_tspp;../../../components/ble/profile/om_wechat_lite;../../../components/ble/mesh/include;../../../components/shell;../../../components/nvds;../../../components/om_log;../../../components/pm;../../../components/evt;../../../components/manu_system/fault_handle;../../../hal/CMSIS/Core/Include;../../../hal/driver/include;../../../hal/device/include;../../../rtos/include;../../../rtos/FreeRTOS/Source/Include;../../../rtos/FreeRTOS/CMSIS/Include;../../../rtos/FreeRTOS/CMSIS/Include1;../../../rtos/FreeRTOS/CMSIS/Config/ARMCM;../../../rtos/FreeRTOS/Source/Portable/GCC;
  asm define: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: ../linker_script/KEIL/cm4f_flash.sct
  link misc: --diag_suppress=L6314 --diag_suppress=L6439W
../../../components/ble/controller/lib/ARM/libblectlr_full.lib
../../../components/ble/host/lib/ARM/libblehost_full.lib
../../../components/ble/mesh/lib/ARM/libblemesh.lib
../../../hal/device/ARM/libcpft.lib
  group main
    ../main/: main.c
  group app
    ../app/: omsh_app.c omsh_app_shell.c omsh_app_hook.c
    ../app/firms/: omsh_app_firms.c omsh_app_firms_mdl.c omsh_app_firms_mdl_demo.c
    ../app/tmall/: omsh_app_tmall.c
  group bsp
    ../../../bsp/board_evb/: board_evb.c
    ../../../bsp/source/: glcd_gc9c01.c glcd_gc9b71.c
  group common
    ../../../common/source/: om_printf.c om_mem.c om_ringbuff.c om_common.c om_fifo.c om_libc_retarget.c om_list.c
  group ble_stack_common
    ../../../components/ble/common/: ob_mem_heap.c
  group profile
    ../../../components/ble/profile/om_ancs/: ancs_client.c
    ../../../components/ble/profile/om_bms/: om_bms.c service_om_bms.c
    ../../../components/ble/profile/om_cgms/: om_cgms.c service_om_cgms.c
    ../../../components/ble/profile/om_dfu/: om_dfu.c om_dfu_nvds.c om_dfu_ver_check.c service_om_dfu.c
    ../../../components/ble/profile/om_gap_dis_batt/: service_common.c
    ../../../components/ble/profile/om_hid_media/: app_hid_media.c
    ../../../components/ble/profile/om_tspp/: service_tspp.c
    ../../../components/ble/profile/om_wechat_lite/: app_wechat_lite.c
  group shell
    ../../../components/shell/: shell_common.c shell_port_rtos.c
  group nvds
    ../../../components/nvds/: nvds.c
  group om_log
    ../../../components/om_log/: om_log.c om_log_port.c
  group pm
    ../../../components/pm/: pm.c pm_cpu_gnu.S
  group evt
    ../../../components/evt/: evt.c evt_timer.c
  group manu_system
    ../../../components/manu_system/fault_handle/: fault_handle.c
  group driver
    ../../../hal/driver/source/: drv_mpu.c drv_om24g.c drv_gpadc.c drv_aes.c drv_calib_repair.c drv_calib.c drv_gpdma.c drv_efuse.c drv_gpio.c drv_i2c.c drv_isr.c drv_lptim.c drv_pin.c drv_pmu_timer.c drv_pmu.c drv_radio.c drv_rcc.c drv_rng.c drv_rtc.c drv_spi.c drv_tim.c drv_uart.c drv_wdt.c drv_i2s.c drv_audio.c drv_audio_inside.c drv_audio_outside.c drv_lcd.c drv_irtx.c drv_sha256.c drv_ospi.c drv_psram.c drv_qdec.c drv_rgb.c
    ../../../hal/driver/source/drv_ecdsa/: drv_ecdsa.c
    ../../../hal/driver/source/drv_ecdsa/uECC/: uECC.c
    ../../../hal/driver/source/drv_flash/: drv_iflash.c drv_oflash.c drv_flash.c
  group startup
    ../../../hal/device/: system_cm4f.c
    ../../../hal/device/GCC/: startup_cm4f.S
  group FreeRTOS
    ../../../rtos/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../rtos/FreeRTOS/Source/Portable/MemMang/: heap_5.c
    ../../../rtos/FreeRTOS/Source/Portable/Common/: mpu_wrappers.c
    ../../../rtos/FreeRTOS/CMSIS/Source/: cmsis_os2.c cmsis_os1.c freertos_evr.c os_systick.c
    ../../../rtos/FreeRTOS/Source/Portable/GCC/: port.c
